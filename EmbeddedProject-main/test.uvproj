# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: test
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: CALC_DISP.c eeprom.c eepromfunc.c GPIO_DRIVER.c main.c NMEA FNS.c systick.c UART_INIT.c CALC_DISP.h eeprom.h GPIO_DRIVER.h STD_TYPES.h stdint.h systick.h tm4c123gh6pm.h UART_INIT.h startup_TM4C123.s
